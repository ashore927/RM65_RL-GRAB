Commit message: 完善基础环境，调整D435

File: URDF/rm65.urdf (robot description, URDF)
Before this commit: robot rm_65_description, 14 links, 13 joints
Joints:
- joint camera_joint: origin xyz=0.0645 0.108 0.01855 rpy=1.5708 -1.5708 3.1416 -> xyz=0.062 0.1215 0.0225 rpy=1.5708 -1.5708 3.1416
